# Keil uVision project clock_show.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: clock_show +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c timer0.h timer0.c type_def.h clock_DS1302.h clock_DS1302.c nexie2.h nexie2.c btn4.h btn4.c
